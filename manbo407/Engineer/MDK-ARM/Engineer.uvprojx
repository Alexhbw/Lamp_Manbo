# Keil uVision project Engineer.uvprojx, settings and files
target Engineer (5050106::V5.05 update 1 (build 106)::ARMCC)
  device: STM32F407IGHx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.14.0
  cpu: IRAM(0x20000000-0x2001BFFF) IRAM2(0x2001C000-0x2001FFFF) IROM(0x8000000-0x80FFFFF) CLOCK(25000000) FPU2 CPUTYPE("Cortex-M4") TZ
  output: Engineer +hex
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: USE_HAL_DRIVER,STM32F407xx
  c include: ../Core/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32F4xx/Include;../Drivers/CMSIS/Include;../MODULE/algorithm;../MODULE/C_comm;../MODULE/motor;../MODULE/motor/DJImotor;../MODULE/motor/DMmotor;../BSP/CAN;../BSP/DWT;../BSP/USART;../APPLICATION;../APPLICATION/arm;../MODULE/remote;../Middlewares/Third_Party/FreeRTOS/Source/include;../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F;../Middlewares/ST/ARM/DSP/Inc;../MODULE/daemon;../MODULE;../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS;../APPLICATION/dribble;../APPLICATION/chassis;../MODULE/imu;../APPLICATION/shoot;../APPLICATION/cmd;../MODULE/relay;../MODULE/miniPC;../MODULE/OLED;..\MODULE\buzzer
  asm include: ../Core/Inc;../Middlewares/ST/ARM/DSP/Inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x1c000
  memory RVCT10: RAM 0x2001c000 size 0x4000
  group Application/MDK-ARM
    ./: startup_stm32f407xx.s
  group Application/User/Core
    ../Core/Src/: main.c gpio.c freertos.c can.c dma.c spi.c tim.c usart.c stm32f4xx_it.c stm32f4xx_hal_msp.c stm32f4xx_hal_timebase_tim.c
  group Drivers/STM32F4xx_HAL_Driver
    ../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_can.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_gpio.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_dma.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_cortex.c stm32f4xx_hal.c stm32f4xx_hal_exti.c stm32f4xx_hal_spi.c stm32f4xx_hal_uart.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f4xx.c
  group BSP
    ../BSP/CAN/: bsp_can.c
    ../BSP/DWT/: bsp_dwt.c
    ../BSP/USART/: bsp_usart.c
  group MODULE
    ../MODULE/algorithm/: controller.c ramp_contorller.c kalman_filter.c QuaternionEKF.c user_lib.c
    ../MODULE/motor/: motor_task.c
    ../MODULE/motor/DJImotor/: DJI_motor.c
    ../MODULE/motor/DMmotor/: dmmotor.c
    ../MODULE/remote/: remote.c
    ../MODULE/daemon/: daemon.c
    ../MODULE/imu/: BMI088driver.c BMI088Middleware.c ins_task.c
    ../MODULE/relay/: relay.c
    ../MODULE/miniPC/: miniPC_process.c
    ../MODULE/OLED/: oled.c
    ../MODULE/buzzer/: bsp_buzzer.c
  group APPLICATION
    ../APPLICATION/chassis/: chassis.c
    ../APPLICATION/arm/: arm.c
    ../APPLICATION/shoot/: shoot.c
    ../APPLICATION/cmd/: robot_cmd.c
    ../APPLICATION/: Test.c
  group Middlewares/FreeRTOS
    ../Middlewares/Third_Party/FreeRTOS/Source/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS/: cmsis_os.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F/: port.c
  group Middlewares/Library/DSP Library/DSP Library
    ../Middlewares/ST/ARM/DSP/Lib/: arm_cortexM4lf_math.lib
software components: CMSIS:CORE 5.4.0
